require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'icu_70.1_agldemo.inc', '', d)}