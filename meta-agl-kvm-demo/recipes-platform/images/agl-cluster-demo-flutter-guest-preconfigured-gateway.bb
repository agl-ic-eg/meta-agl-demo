require agl-cluster-demo-flutter-guest-preconfigured.bb

SUMMARY = "AGL KVM + gateway demo preconfigured guest cluster Flutter image"

FLUTTER_CLUSTER_DASHBOARD_CONF = "flutter-cluster-dashboard-conf-gateway-demo"
