require agl-ivi-demo-flutter-guest-preconfigured.bb

SUMMARY = "AGL KVM + gateway demo preconfigured guest IVI Flutter image"

FLUTTER_ICS_HOMESCREEN_CONF = "flutter-ics-homescreen-conf-kvm-gateway-demo"
ONDEMANDNAVI_CONF = "ondemandnavi-conf-gateway-demo"
TBTNAVI_CONF = "tbtnavi-conf-gateway-demo"
