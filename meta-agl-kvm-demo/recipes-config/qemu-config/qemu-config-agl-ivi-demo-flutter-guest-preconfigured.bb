require qemu-config-agl-ivi-demo-flutter-guest.bb

QEMU_IMAGE = "agl-ivi-demo-flutter-guest-preconfigured"
