require qemu-config-agl-cluster-demo-flutter-guest.bb

QEMU_IMAGE = "agl-cluster-demo-flutter-guest-preconfigured"
