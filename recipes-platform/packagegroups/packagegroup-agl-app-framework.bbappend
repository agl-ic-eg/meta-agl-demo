RDEPENDS:${PN}:append = " systemd-agl-sync run-agl-postinsts"
