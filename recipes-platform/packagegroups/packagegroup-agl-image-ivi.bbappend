RDEPENDS:${PN} += " \
	packagegroup-agl-ivi-identity \
	packagegroup-agl-ivi-services \
"
