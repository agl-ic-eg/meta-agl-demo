RDEPENDS:${PN}:append = "\
        pyagl \
        gcov \
        gcov-symlinks \
        gcovr \
        gcovr-wrapper \
        jq \
        htop \
        tree \
"
