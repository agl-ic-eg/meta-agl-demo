
RDEPENDS:${PN} += "\
    agl-service-nfc \
"

