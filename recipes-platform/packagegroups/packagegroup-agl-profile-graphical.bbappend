RDEPENDS:${PN} += "\
    packagegroup-agl-graphical-services \
"
