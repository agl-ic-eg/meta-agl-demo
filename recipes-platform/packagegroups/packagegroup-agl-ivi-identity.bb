inherit packagegroup

RDEPENDS:${PN} += "\
    agl-service-data-persistence \
    agl-service-identity-agent \
"

LICENSE = "MIT"

