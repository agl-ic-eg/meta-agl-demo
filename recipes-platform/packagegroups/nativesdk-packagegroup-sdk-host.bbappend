RDEPENDS:${PN} =+ "nativesdk-af-main-tools nativesdk-af-binder-devtools"
RDEPENDS:${PN} += "nativesdk-low-level-can-generator \
		nativesdk-cmake-apps-module \
		nativesdk-cmake-apps-module-doc \
"

