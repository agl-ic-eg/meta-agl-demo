require agl-cluster-demo-flutter-preconfigured.bb

SUMMARY = "AGL Cluster preconfigured gateway demo Flutter image"

# Cluster application configuration needs to be replaced for
# the full demo to handle different databroker configuration.
FLUTTER_CLUSTER_DASHBOARD_CONF = "flutter-cluster-dashboard-conf-gateway-demo"

