require agl-ivi-demo-control-panel.bb

SUMMARY = "AGL full demo control panel image"

IMAGE_INSTALL += " \
    agl-demo-control-panel-conf-demo \
"
