require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'weston_13.0_aglcore.inc', '', d)}
