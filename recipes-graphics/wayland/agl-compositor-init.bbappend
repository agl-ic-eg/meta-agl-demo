require ${@bb.utils.contains('AGL_FEATURES', 'agl-container-guest-demo', 'agl-compositor-init_agl-container-guest-demo.inc', '', d)}
