require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'ttf-noto-emoji_agldemo.inc', '', d)}
