SYSTEMD_SERVICE_AFTER:append = " afm-system-daemon.service"
