require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'python3-pyqt6_agldemo.inc', '', d)}
