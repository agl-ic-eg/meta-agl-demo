require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'python3-pyqt5_agldemo.inc', '', d)}
