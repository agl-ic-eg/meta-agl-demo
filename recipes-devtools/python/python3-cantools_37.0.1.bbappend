RDEPENDS:${PN} += "\
    python3-diskcache \
    python3-argparse-addons \
"
