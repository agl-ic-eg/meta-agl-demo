SUMMARY = "Additional Python argparse types and actions."
HOMEPAGE = "https://github.com/eerimoq/argparse_addons"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=515e9da3e929c7b40dd13458363110a7"

PYPI_PACKAGE = "argparse_addons"

SRC_URI[sha256sum] = "f5da0fe676953e39bee7a6d0a9b2f5ccdcbf9d6a6b9929997caf8f6c6b23a5fb"

inherit pypi setuptools3
