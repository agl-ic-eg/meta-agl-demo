PYQT_MODULES:append = " \
    QtWidgets \
    QtSvg \
"