require ${@bb.utils.contains('AGL_FEATURES', 'agl-container-guest-demo', 'agl-session_agl-container-guest-demo.inc', '', d)}
