require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'packagegroup-qt6-modules_agldemo.inc', '', d)}
