require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'packagegroup-qt6-addons_agldemo.inc', '', d)}
