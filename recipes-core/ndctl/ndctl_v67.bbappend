require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', 'ndctl_agldemo.inc', '', d)}
